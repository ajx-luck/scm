# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: CMS8M3510 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(48000000) MODDP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\Libary\StdDriver\inc;..\Libary\Device\CMS8M3510\Include
  link misc: REMOVEUNUSED
  group CMS
    ../Libary/Device/CMS8M3510/: startup_cms8m3510.A51
  group LIB
    ../Libary/StdDriver/src/: acmp.c adc.c buzzer.c epwm.c extint.c flash.c gpio.c i2c.c lse.c opa.c pga.c spi.c system.c timer.c uart.c wdt.c
  group User
    ../code/: isr.c main.c
