# Keil uVision project led.uvproj, settings and files
target Target 1 (MCS-51)
  device: CMS8S5880 CMS
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x01FF) CLOCK(50000000) MODDP2
  output: Target 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP_CMS8S5880.A51 led.c
