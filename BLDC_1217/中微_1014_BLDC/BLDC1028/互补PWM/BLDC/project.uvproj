# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: KCM363-25-10-11-拨动开关 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRV
  group Source Group 1
    ./DRV/: init.c adc.c button.c vsp.c motor.c main.c flash.c uart.c
